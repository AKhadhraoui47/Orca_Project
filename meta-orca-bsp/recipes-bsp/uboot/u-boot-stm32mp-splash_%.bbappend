FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

UBOOT_SPLASH_LANDSCAPE_SRC = "orca_splash_H.bmp"
UBOOT_SPLASH_PORTRAIT_SRC = "orca_splash_V.bmp"