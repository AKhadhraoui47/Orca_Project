PACKAGECONFIG:remove = " \
    backlight \
    hibernate \
    idn \
    kmod \
    localed \
    nss \
    nss-mymachines \
    nss-resolve \
    machined \
    networkd \
    quotacheck \
    randomseed \
    resolved \
    sysvinit \
    timedated \
    timesyncd \
    userdb \
    utmp \
    vconsole \
    wheel-group \
    "