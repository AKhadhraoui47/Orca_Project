SUMMARY = "Calf Development Image"
DESCRIPTION = "This recipe provides a full-featured image with a set of development tools, compiler, libraries and debugging and profiling tools as dgb and strace"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=801f80980d171dd6425610833a22dbe6"

inherit calf-image

CALF_TYPE = "calfdev"
