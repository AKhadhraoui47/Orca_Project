SUMMARY = "Orca Core Image"
DESCRIPTION = "This minimal recipe provides a minimal image just able to boot"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=801f80980d171dd6425610833a22dbe6"

inherit orca-image

ORCA_TYPE = "orcadev"
